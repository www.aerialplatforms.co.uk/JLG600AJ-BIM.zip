Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-03-15T11:54:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 15 11:54:13 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{72C2C3DE-F011-42FE-85D8-E9D683A40BD1}\ifc * Database version: 5507 * Database creation date: Thu Mar 15 11:54:05 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 15 11:54:05 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 15 11:54:05 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcTransportElement: Stowed Position, 1001160000_600AJ:Stowed Position:207285
In: Level 1
Type - PredefinedType: ELEVATOR; Material: JLG_Plastic_Red, JLG_Plastic_Green, JLG_Rubber_Black, JLG_Plastic_Yellow, JLG_Metal Paint_White, JLG_Metal Paint_Black, JLG_Paint_Orange, JLG_Paint_Beige, JLG_Plastic_Dark Grey, JLG_Glass_Red, Metal, JLG_Steel
Type - Constraints - A: 90 mm; Aa: 1 deg; AE: 70 mm; AEa: -9 deg; Ja: -47.15 deg; Reach: 0
Type - Data - Auxiliary Power: 12v-DC; Axle Oscillation: 0.19 m (0 ft 7.5 in); Diesel Engine: Deutz D2011L04 36.4 kW; Drive Speed 2WD: 6.8 kph (4.2 mph); Drive Speed 4WD: 6.8 kph (4.2 mph); Fuel Tank Capacity: 113.6 L (30 gal); Gradeability 2WD: 30%; Gradeability 4WD: 40%; Horizontal Outreach: 12.10 m (39 ft 8 in); Hydraulic Tank Capacity: 115.8 L (30.6 gal); Jib – Overall Length: 1.83m ( 6 ft 0 in); Jib Range of Articulation: 130° (+70° / - 60°); Machine weight 2WS (ANSI): 10,088 kg (22,240 lbs); Machine weight 2WS (CE): 10,660 kg (23,501 lbs); Max Ground Bearing Pressure (ANSI): 5.25 kg/cm2 (75 psi); Max Ground Bearing Pressure (CE): 5.5 kg/cm2 (75 psi); Platform Capacity (ANSI): 227 kg (500 lbs); Platform Capacity (CE): 230kg (507 lbs); Platform Height: 18.47 m (60 ft 7 in); Platform Rotator: 180°; Platform Size: 0.91 m x 2.44 m (3 ft 0 in x 8 ft 0 in); Swing: 360 Degrees Continuous; Turning Radius Inside 2WS: 3.33 m ( 10 ft 11 in); Turning Radius Inside 4WS: 1.41 m ( 4 ft 7 in); Turning Radius Outside 2WS: 5.36m ( 17 ft 7 in); Turning Radius Outside 4WS: 2.89 m ( 9 ft 6 in); Tyres: 355/55 D625 Foam Filled; Up and Over Height: 8.10 m (26 ft 7 in)
Type - Dimensions - Aa1: 271 deg; AEa1: 261 deg; AHa: 1 deg; AHa1: 91 deg; Ja1: 132.85 deg; JHa: -9 deg; JHa1: 171 deg; PH1a: 47.15 deg; PH1a1: 137.15 deg; PH2a: -38.15 deg; PH2a1: 51.85 deg
Type - General - Articulating Jib: 1.83 m (6 ft 0 in)articulating jib; Hydraulic Platform Rotator: 180 degree powered platform rotator; Platform Side Entry: 0.91 m x 2.44 m low mount platform; Tilt Alarm/Indicator Light: 4 Degrees CE/AUST, 5 Degree Japan
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: Stowed Position
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001160000_600AJ; NBSDescription: Articulating Boom Lift; NBSNote: n/a; NBSObjectName: JLG 600AJ_Articulating Boom Lift; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: Elevators; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001160000_600AJ; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: 600AJ; ModelReference: JLG - Articulating Boom Lift; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Articulating Boom Lift; Manufacturer: JLG; ProductionYear: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 559.847 m2; Platform Rotation: 0 deg; PR: 0 deg; Reach Diagram: no; Sa1: 180 deg; Swing_Angle: 0 deg; Turning Radius_2WS: no; Turning Radius_4WS: no; Volume: 4.54959 m3; Working Area: no
Identity Data - Mark: 2
Other - Family: 1001160000_600AJ: Stowed Position; Family and Type: 1001160000_600AJ: Stowed Position; Type: 1001160000_600AJ: Stowed Position; Type Id: 1001160000_600AJ: Stowed Position; WarrantyStartDate (default): Please Record On Commissioning
Phasing - Phase Created: Phase 1
